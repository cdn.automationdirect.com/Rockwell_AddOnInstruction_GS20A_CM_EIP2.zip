(* Logix 5000 Module export GS20A_CM_EIP2; software revision 37.00 *)

MODULES
   GS20A_CM_EIP2 : GS20A-CM-EIP2 (Ethernet 10.11.0.50, rev 1.1, StandardDataDriven RPI 250 ms)
END_MODULES
